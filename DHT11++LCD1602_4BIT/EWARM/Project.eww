<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\DHT11++LCD1602_4BIT.ewp</path>
  </project>
  <batchBuild />
</workspace>
